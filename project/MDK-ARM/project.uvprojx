# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G070KBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ..\user_code; ..\TencentOS-tiny; ..\TencentOS-tiny\arch\arm\arm-v7m\cortex-m0+\armcc; ..\TencentOS-tiny\kernel\core\include; ..\TencentOS-tiny\arch\arm\arm-v7m\common\include; ..\qcloud-iot-sdk-tencent-at-based\include; ..\qcloud-iot-sdk-tencent-at-based\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/User
    ./: startup_stm32g070xx.s
    ../Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_gpio.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
  group UserCode
    ../user_code/: ws2812_driver.c user_utils.c hlw8032.c key.c user_task.c
  group TencentOS-tiny
    ../TencentOS-tiny/arch/arm/arm-v7m/cortex-m0+/armcc/: port_c.c port_s.S
    ../TencentOS-tiny/kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
    ../TencentOS-tiny/arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
  group qcloud-iot-sdk-tencent-at-based
    ../qcloud-iot-sdk-tencent-at-based/port/: hal_at.c hal_os.c
    ../qcloud-iot-sdk-tencent-at-based/src/data_template/: data_template_aciton.c data_template_client.c data_template_client_common.c data_template_client_json.c data_template_client_manager.c data_template_event.c
    ../qcloud-iot-sdk-tencent-at-based/src/module_at/: at_client.c at_log.c at_timer.c at_utils.c iot_device.c module_api_inf.c ringbuff.c
    ../qcloud-iot-sdk-tencent-at-based/src/mqtt/: mqtt.c
    ../qcloud-iot-sdk-tencent-at-based/src/utils/: json_parser.c json_token.c string_utils.c utils_list.c utils_timer.c
    ../qcloud-iot-sdk-tencent-at-based/usr_logic/: data_template_usr_logic.c
software components: CMSIS:CORE 4.3.0
